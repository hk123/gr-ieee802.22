<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8rc1'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tx_rx_802_22</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>1710e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header_formatter</value></param>
<param><key>value</key><value>digital.packet_header_ofdm(occupied_carriers, 1, length_tag_key)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header_mod</value></param>
<param><key>value</key><value>digital.constellation_bpsk()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length_tag_key</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lts</value></param>
<param><key>value</key><value>[0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0,1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0,-1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0,-1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0,1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0,1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0,-1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0,1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 0, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0,1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, -1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 1.4142135623731, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>value</key><value>([-839, -838, -837, -836, -835, -834, -832, -831, -830, -829, -828, -827, -825, -824, -823, -822, -821, -820, -818, -817, -816, -815, -814, -813, -811, -810, -809, -808, -807, -806, -804, -803, -802, -801, -800, -799, -797, -796, -795, -794, -793, -792, -790, -789, -788, -787, -786, -785, -783, -782, -781, -780, -779, -778, -776, -775, -774, -773, -772, -771, -769, -768, -767, -766, -765, -764, -762, -761, -760, -759, -758, -757, -755, -754, -753, -752, -751, -750, -748, -747, -746, -745, -744, -743, -741, -740, -739, -738, -737, -736, -734, -733, -732, -731, -730, -729, -727, -726, -725, -724, -723, -722, -720, -719, -718, -717, -716, -715, -713, -712, -711, -710, -709, -708, -706, -705, -704, -703, -702, -701, -699, -698, -697, -696, -695, -694, -692, -691, -690, -689, -688, -687, -685, -684, -683, -682, -681, -680, -678, -677, -676, -675, -674, -673, -671, -670, -669, -668, -667, -666, -664, -663, -662, -661, -660, -659, -657, -656, -655, -654, -653, -652, -650, -649, -648, -647, -646, -645, -643, -642, -641, -640, -639, -638, -636, -635, -634, -633, -632, -631, -629, -628, -627, -626, -625, -624, -622, -621, -620, -619, -618, -617, -615, -614, -613, -612, -611, -610, -608, -607, -606, -605, -604, -603, -601, -600, -599, -598, -597, -596, -594, -593, -592, -591, -590, -589, -587, -586, -585, -584, -583, -582, -580, -579, -578, -577, -576, -575, -573, -572, -571, -570, -569, -568, -566, -565, -564, -563, -562, -561, -559, -558, -557, -556, -555, -554, -552, -551, -550, -549, -548, -547, -545, -544, -543, -542, -541, -540, -538, -537, -536, -535, -534, -533, -531, -530, -529, -528, -527, -526, -524, -523, -522, -521, -520, -519, -517, -516, -515, -514, -513, -512, -510, -509, -508, -507, -506, -505, -503, -502, -501, -500, -499, -498, -496, -495, -494, -493, -492, -491, -489, -488, -487, -486, -485, -484, -482, -481, -480, -479, -478, -477, -475, -474, -473, -472, -471, -470, -468, -467, -466, -465, -464, -463, -461, -460, -459, -458, -457, -456, -454, -453, -452, -451, -450, -449, -447, -446, -445, -444, -443, -442, -440, -439, -438, -437, -436, -435, -433, -432, -431, -430, -429, -428, -426, -425, -424, -423, -422, -421, -419, -418, -417, -416, -415, -414, -412, -411, -410, -409, -408, -407, -405, -404, -403, -402, -401, -400, -398, -397, -396, -395, -394, -393, -391, -390, -389, -388, -387, -386, -384, -383, -382, -381, -380, -379, -377, -376, -375, -374, -373, -372, -370, -369, -368, -367, -366, -365, -363, -362, -361, -360, -359, -358, -356, -355, -354, -353, -352, -351, -349, -348, -347, -346, -345, -344, -342, -341, -340, -339, -338, -337, -335, -334, -333, -332, -331, -330, -328, -327, -326, -325, -324, -323, -321, -320, -319, -318, -317, -316, -314, -313, -312, -311, -310, -309, -307, -306, -305, -304, -303, -302, -300, -299, -298, -297, -296, -295, -293, -292, -291, -290, -289, -288, -286, -285, -284, -283, -282, -281, -279, -278, -277, -276, -275, -274, -272, -271, -270, -269, -268, -267, -265, -264, -263, -262, -261, -260, -258, -257, -256, -255, -254, -253, -251, -250, -249, -248, -247, -246, -244, -243, -242, -241, -240, -239, -237, -236, -235, -234, -233, -232, -230, -229, -228, -227, -226, -225, -223, -222, -221, -220, -219, -218, -216, -215, -214, -213, -212, -211, -209, -208, -207, -206, -205, -204, -202, -201, -200, -199, -198, -197, -195, -194, -193, -192, -191, -190, -188, -187, -186, -185, -184, -183, -181, -180, -179, -178, -177, -176, -174, -173, -172, -171, -170, -169, -167, -166, -165, -164, -163, -162, -160, -159, -158, -157, -156, -155, -153, -152, -151, -150, -149, -148, -146, -145, -144, -143, -142, -141, -139, -138, -137, -136, -135, -134, -132, -131, -130, -129, -128, -127, -125, -124, -123, -122, -121, -120, -118, -117, -116, -115, -114, -113, -111, -110, -109, -108, -107, -106, -104, -103, -102, -101, -100, -99, -97, -96, -95, -94, -93, -92, -90, -89, -88, -87, -86, -85, -83, -82, -81, -80, -79, -78, -76, -75, -74, -73, -72, -71, -69, -68, -67, -66, -65, -64, -62, -61, -60, -59, -58, -57, -55, -54, -53, -52, -51, -50, -48, -47, -46, -45, -44, -43, -41, -40, -39, -38, -37, -36, -34, -33, -32, -31, -30, -29, -27, -26, -25, -24, -23, -22, -20, -19, -18, -17, -16, -15, -13, -12, -11, -10, -9, -8, -6, -5, -4, -3, -2, -1, 2, 3, 4, 5, 6, 7, 9, 10, 11, 12, 13, 14, 16, 17, 18, 19, 20, 21, 23, 24, 25, 26, 27, 28, 30, 31, 32, 33, 34, 35, 37, 38, 39, 40, 41, 42, 44, 45, 46, 47, 48, 49, 51, 52, 53, 54, 55, 56, 58, 59, 60, 61, 62, 63, 65, 66, 67, 68, 69, 70, 72, 73, 74, 75, 76, 77, 79, 80, 81, 82, 83, 84, 86, 87, 88, 89, 90, 91, 93, 94, 95, 96, 97, 98, 100, 101, 102, 103, 104, 105, 107, 108, 109, 110, 111, 112, 114, 115, 116, 117, 118, 119, 121, 122, 123, 124, 125, 126, 128, 129, 130, 131, 132, 133, 135, 136, 137, 138, 139, 140, 142, 143, 144, 145, 146, 147, 149, 150, 151, 152, 153, 154, 156, 157, 158, 159, 160, 161, 163, 164, 165, 166, 167, 168, 170, 171, 172, 173, 174, 175, 177, 178, 179, 180, 181, 182, 184, 185, 186, 187, 188, 189, 191, 192, 193, 194, 195, 196, 198, 199, 200, 201, 202, 203, 205, 206, 207, 208, 209, 210, 212, 213, 214, 215, 216, 217, 219, 220, 221, 222, 223, 224, 226, 227, 228, 229, 230, 231, 233, 234, 235, 236, 237, 238, 240, 241, 242, 243, 244, 245, 247, 248, 249, 250, 251, 252, 254, 255, 256, 257, 258, 259, 261, 262, 263, 264, 265, 266, 268, 269, 270, 271, 272, 273, 275, 276, 277, 278, 279, 280, 282, 283, 284, 285, 286, 287, 289, 290, 291, 292, 293, 294, 296, 297, 298, 299, 300, 301, 303, 304, 305, 306, 307, 308, 310, 311, 312, 313, 314, 315, 317, 318, 319, 320, 321, 322, 324, 325, 326, 327, 328, 329, 331, 332, 333, 334, 335, 336, 338, 339, 340, 341, 342, 343, 345, 346, 347, 348, 349, 350, 352, 353, 354, 355, 356, 357, 359, 360, 361, 362, 363, 364, 366, 367, 368, 369, 370, 371, 373, 374, 375, 376, 377, 378, 380, 381, 382, 383, 384, 385, 387, 388, 389, 390, 391, 392, 394, 395, 396, 397, 398, 399, 401, 402, 403, 404, 405, 406, 408, 409, 410, 411, 412, 413, 415, 416, 417, 418, 419, 420, 422, 423, 424, 425, 426, 427, 429, 430, 431, 432, 433, 434, 436, 437, 438, 439, 440, 441, 443, 444, 445, 446, 447, 448, 450, 451, 452, 453, 454, 455, 457, 458, 459, 460, 461, 462, 464, 465, 466, 467, 468, 469, 471, 472, 473, 474, 475, 476, 478, 479, 480, 481, 482, 483, 485, 486, 487, 488, 489, 490, 492, 493, 494, 495, 496, 497, 499, 500, 501, 502, 503, 504, 506, 507, 508, 509, 510, 511, 513, 514, 515, 516, 517, 518, 520, 521, 522, 523, 524, 525, 527, 528, 529, 530, 531, 532, 534, 535, 536, 537, 538, 539, 541, 542, 543, 544, 545, 546, 548, 549, 550, 551, 552, 553, 555, 556, 557, 558, 559, 560, 562, 563, 564, 565, 566, 567, 569, 570, 571, 572, 573, 574, 576, 577, 578, 579, 580, 581, 583, 584, 585, 586, 587, 588, 590, 591, 592, 593, 594, 595, 597, 598, 599, 600, 601, 602, 604, 605, 606, 607, 608, 609, 611, 612, 613, 614, 615, 616, 618, 619, 620, 621, 622, 623, 625, 626, 627, 628, 629, 630, 632, 633, 634, 635, 636, 637, 639, 640, 641, 642, 643, 644, 646, 647, 648, 649, 650, 651, 653, 654, 655, 656, 657, 658, 660, 661, 662, 663, 664, 665, 667, 668, 669, 670, 671, 672, 674, 675, 676, 677, 678, 679, 681, 682, 683, 684, 685, 686, 688, 689, 690, 691, 692, 693, 695, 696, 697, 698, 699, 700, 702, 703, 704, 705, 706, 707, 709, 710, 711, 712, 713, 714, 716, 717, 718, 719, 720, 721, 723, 724, 725, 726, 727, 728, 730, 731, 732, 733, 734, 735, 737, 738, 739, 740, 741, 742, 744, 745, 746, 747, 748, 749, 751, 752, 753, 754, 755, 756, 758, 759, 760, 761, 762, 763, 765, 766, 767, 768, 769, 770, 772, 773, 774, 775, 776, 777, 779, 780, 781, 782, 783, 784, 786, 787, 788, 789, 790, 791, 793, 794, 795, 796, 797, 798, 800, 801, 802, 803, 804, 805, 807, 808, 809, 810, 811, 812, 814, 815, 816, 817, 818, 819, 821, 822, 823, 824, 825, 826, 828, 829, 830, 831, 832, 833, 835, 836, 837, 838, 839, 840], [-840, -839, -838, -836, -835, -834, -833, -832, -831, -829, -828, -827, -826, -825, -824, -822, -821, -820, -819, -818, -817, -815, -814, -813, -812, -811, -810, -808, -807, -806, -805, -804, -803, -801, -800, -799, -798, -797, -796, -794, -793, -792, -791, -790, -789, -787, -786, -785, -784, -783, -782, -780, -779, -778, -777, -776, -775, -773, -772, -771, -770, -769, -768, -766, -765, -764, -763, -762, -761, -759, -758, -757, -756, -755, -754, -752, -751, -750, -749, -748, -747, -745, -744, -743, -742, -741, -740, -738, -737, -736, -735, -734, -733, -731, -730, -729, -728, -727, -726, -724, -723, -722, -721, -720, -719, -717, -716, -715, -714, -713, -712, -710, -709, -708, -707, -706, -705, -703, -702, -701, -700, -699, -698, -696, -695, -694, -693, -692, -691, -689, -688, -687, -686, -685, -684, -682, -681, -680, -679, -678, -677, -675, -674, -673, -672, -671, -670, -668, -667, -666, -665, -664, -663, -661, -660, -659, -658, -657, -656, -654, -653, -652, -651, -650, -649, -647, -646, -645, -644, -643, -642, -640, -639, -638, -637, -636, -635, -633, -632, -631, -630, -629, -628, -626, -625, -624, -623, -622, -621, -619, -618, -617, -616, -615, -614, -612, -611, -610, -609, -608, -607, -605, -604, -603, -602, -601, -600, -598, -597, -596, -595, -594, -593, -591, -590, -589, -588, -587, -586, -584, -583, -582, -581, -580, -579, -577, -576, -575, -574, -573, -572, -570, -569, -568, -567, -566, -565, -563, -562, -561, -560, -559, -558, -556, -555, -554, -553, -552, -551, -549, -548, -547, -546, -545, -544, -542, -541, -540, -539, -538, -537, -535, -534, -533, -532, -531, -530, -528, -527, -526, -525, -524, -523, -521, -520, -519, -518, -517, -516, -514, -513, -512, -511, -510, -509, -507, -506, -505, -504, -503, -502, -500, -499, -498, -497, -496, -495, -493, -492, -491, -490, -489, -488, -486, -485, -484, -483, -482, -481, -479, -478, -477, -476, -475, -474, -472, -471, -470, -469, -468, -467, -465, -464, -463, -462, -461, -460, -458, -457, -456, -455, -454, -453, -451, -450, -449, -448, -447, -446, -444, -443, -442, -441, -440, -439, -437, -436, -435, -434, -433, -432, -430, -429, -428, -427, -426, -425, -423, -422, -421, -420, -419, -418, -416, -415, -414, -413, -412, -411, -409, -408, -407, -406, -405, -404, -402, -401, -400, -399, -398, -397, -395, -394, -393, -392, -391, -390, -388, -387, -386, -385, -384, -383, -381, -380, -379, -378, -377, -376, -374, -373, -372, -371, -370, -369, -367, -366, -365, -364, -363, -362, -360, -359, -358, -357, -356, -355, -353, -352, -351, -350, -349, -348, -346, -345, -344, -343, -342, -341, -339, -338, -337, -336, -335, -334, -332, -331, -330, -329, -328, -327, -325, -324, -323, -322, -321, -320, -318, -317, -316, -315, -314, -313, -311, -310, -309, -308, -307, -306, -304, -303, -302, -301, -300, -299, -297, -296, -295, -294, -293, -292, -290, -289, -288, -287, -286, -285, -283, -282, -281, -280, -279, -278, -276, -275, -274, -273, -272, -271, -269, -268, -267, -266, -265, -264, -262, -261, -260, -259, -258, -257, -255, -254, -253, -252, -251, -250, -248, -247, -246, -245, -244, -243, -241, -240, -239, -238, -237, -236, -234, -233, -232, -231, -230, -229, -227, -226, -225, -224, -223, -222, -220, -219, -218, -217, -216, -215, -213, -212, -211, -210, -209, -208, -206, -205, -204, -203, -202, -201, -199, -198, -197, -196, -195, -194, -192, -191, -190, -189, -188, -187, -185, -184, -183, -182, -181, -180, -178, -177, -176, -175, -174, -173, -171, -170, -169, -168, -167, -166, -164, -163, -162, -161, -160, -159, -157, -156, -155, -154, -153, -152, -150, -149, -148, -147, -146, -145, -143, -142, -141, -140, -139, -138, -136, -135, -134, -133, -132, -131, -129, -128, -127, -126, -125, -124, -122, -121, -120, -119, -118, -117, -115, -114, -113, -112, -111, -110, -108, -107, -106, -105, -104, -103, -101, -100, -99, -98, -97, -96, -94, -93, -92, -91, -90, -89, -87, -86, -85, -84, -83, -82, -80, -79, -78, -77, -76, -75, -73, -72, -71, -70, -69, -68, -66, -65, -64, -63, -62, -61, -59, -58, -57, -56, -55, -54, -52, -51, -50, -49, -48, -47, -45, -44, -43, -42, -41, -40, -38, -37, -36, -35, -34, -33, -31, -30, -29, -28, -27, -26, -24, -23, -22, -21, -20, -19, -17, -16, -15, -14, -13, -12, -10, -9, -8, -7, -6, -5, -3, -2, -1, 1, 2, 3, 5, 6, 7, 8, 9, 10, 12, 13, 14, 15, 16, 17, 19, 20, 21, 22, 23, 24, 26, 27, 28, 29, 30, 31, 33, 34, 35, 36, 37, 38, 40, 41, 42, 43, 44, 45, 47, 48, 49, 50, 51, 52, 54, 55, 56, 57, 58, 59, 61, 62, 63, 64, 65, 66, 68, 69, 70, 71, 72, 73, 75, 76, 77, 78, 79, 80, 82, 83, 84, 85, 86, 87, 89, 90, 91, 92, 93, 94, 96, 97, 98, 99, 100, 101, 103, 104, 105, 106, 107, 108, 110, 111, 112, 113, 114, 115, 117, 118, 119, 120, 121, 122, 124, 125, 126, 127, 128, 129, 131, 132, 133, 134, 135, 136, 138, 139, 140, 141, 142, 143, 145, 146, 147, 148, 149, 150, 152, 153, 154, 155, 156, 157, 159, 160, 161, 162, 163, 164, 166, 167, 168, 169, 170, 171, 173, 174, 175, 176, 177, 178, 180, 181, 182, 183, 184, 185, 187, 188, 189, 190, 191, 192, 194, 195, 196, 197, 198, 199, 201, 202, 203, 204, 205, 206, 208, 209, 210, 211, 212, 213, 215, 216, 217, 218, 219, 220, 222, 223, 224, 225, 226, 227, 229, 230, 231, 232, 233, 234, 236, 237, 238, 239, 240, 241, 243, 244, 245, 246, 247, 248, 250, 251, 252, 253, 254, 255, 257, 258, 259, 260, 261, 262, 264, 265, 266, 267, 268, 269, 271, 272, 273, 274, 275, 276, 278, 279, 280, 281, 282, 283, 285, 286, 287, 288, 289, 290, 292, 293, 294, 295, 296, 297, 299, 300, 301, 302, 303, 304, 306, 307, 308, 309, 310, 311, 313, 314, 315, 316, 317, 318, 320, 321, 322, 323, 324, 325, 327, 328, 329, 330, 331, 332, 334, 335, 336, 337, 338, 339, 341, 342, 343, 344, 345, 346, 348, 349, 350, 351, 352, 353, 355, 356, 357, 358, 359, 360, 362, 363, 364, 365, 366, 367, 369, 370, 371, 372, 373, 374, 376, 377, 378, 379, 380, 381, 383, 384, 385, 386, 387, 388, 390, 391, 392, 393, 394, 395, 397, 398, 399, 400, 401, 402, 404, 405, 406, 407, 408, 409, 411, 412, 413, 414, 415, 416, 418, 419, 420, 421, 422, 423, 425, 426, 427, 428, 429, 430, 432, 433, 434, 435, 436, 437, 439, 440, 441, 442, 443, 444, 446, 447, 448, 449, 450, 451, 453, 454, 455, 456, 457, 458, 460, 461, 462, 463, 464, 465, 467, 468, 469, 470, 471, 472, 474, 475, 476, 477, 478, 479, 481, 482, 483, 484, 485, 486, 488, 489, 490, 491, 492, 493, 495, 496, 497, 498, 499, 500, 502, 503, 504, 505, 506, 507, 509, 510, 511, 512, 513, 514, 516, 517, 518, 519, 520, 521, 523, 524, 525, 526, 527, 528, 530, 531, 532, 533, 534, 535, 537, 538, 539, 540, 541, 542, 544, 545, 546, 547, 548, 549, 551, 552, 553, 554, 555, 556, 558, 559, 560, 561, 562, 563, 565, 566, 567, 568, 569, 570, 572, 573, 574, 575, 576, 577, 579, 580, 581, 582, 583, 584, 586, 587, 588, 589, 590, 591, 593, 594, 595, 596, 597, 598, 600, 601, 602, 603, 604, 605, 607, 608, 609, 610, 611, 612, 614, 615, 616, 617, 618, 619, 621, 622, 623, 624, 625, 626, 628, 629, 630, 631, 632, 633, 635, 636, 637, 638, 639, 640, 642, 643, 644, 645, 646, 647, 649, 650, 651, 652, 653, 654, 656, 657, 658, 659, 660, 661, 663, 664, 665, 666, 667, 668, 670, 671, 672, 673, 674, 675, 677, 678, 679, 680, 681, 682, 684, 685, 686, 687, 688, 689, 691, 692, 693, 694, 695, 696, 698, 699, 700, 701, 702, 703, 705, 706, 707, 708, 709, 710, 712, 713, 714, 715, 716, 717, 719, 720, 721, 722, 723, 724, 726, 727, 728, 729, 730, 731, 733, 734, 735, 736, 737, 738, 740, 741, 742, 743, 744, 745, 747, 748, 749, 750, 751, 752, 754, 755, 756, 757, 758, 759, 761, 762, 763, 764, 765, 766, 768, 769, 770, 771, 772, 773, 775, 776, 777, 778, 779, 780, 782, 783, 784, 785, 786, 787, 789, 790, 791, 792, 793, 794, 796, 797, 798, 799, 800, 801, 803, 804, 805, 806, 807, 808, 810, 811, 812, 813, 814, 815, 817, 818, 819, 820, 821, 822, 824, 825, 826, 827, 828, 829, 831, 832, 833, 834, 835, 836, 838, 839, 840], [-840, -839, -838, -837, -836, -834, -833, -832, -831, -830, -829, -827, -826, -825, -824, -823, -822, -820, -819, -818, -817, -816, -815, -813, -812, -811, -810, -809, -808, -806, -805, -804, -803, -802, -801, -799, -798, -797, -796, -795, -794, -792, -791, -790, -789, -788, -787, -785, -784, -783, -782, -781, -780, -778, -777, -776, -775, -774, -773, -771, -770, -769, -768, -767, -766, -764, -763, -762, -761, -760, -759, -757, -756, -755, -754, -753, -752, -750, -749, -748, -747, -746, -745, -743, -742, -741, -740, -739, -738, -736, -735, -734, -733, -732, -731, -729, -728, -727, -726, -725, -724, -722, -721, -720, -719, -718, -717, -715, -714, -713, -712, -711, -710, -708, -707, -706, -705, -704, -703, -701, -700, -699, -698, -697, -696, -694, -693, -692, -691, -690, -689, -687, -686, -685, -684, -683, -682, -680, -679, -678, -677, -676, -675, -673, -672, -671, -670, -669, -668, -666, -665, -664, -663, -662, -661, -659, -658, -657, -656, -655, -654, -652, -651, -650, -649, -648, -647, -645, -644, -643, -642, -641, -640, -638, -637, -636, -635, -634, -633, -631, -630, -629, -628, -627, -626, -624, -623, -622, -621, -620, -619, -617, -616, -615, -614, -613, -612, -610, -609, -608, -607, -606, -605, -603, -602, -601, -600, -599, -598, -596, -595, -594, -593, -592, -591, -589, -588, -587, -586, -585, -584, -582, -581, -580, -579, -578, -577, -575, -574, -573, -572, -571, -570, -568, -567, -566, -565, -564, -563, -561, -560, -559, -558, -557, -556, -554, -553, -552, -551, -550, -549, -547, -546, -545, -544, -543, -542, -540, -539, -538, -537, -536, -535, -533, -532, -531, -530, -529, -528, -526, -525, -524, -523, -522, -521, -519, -518, -517, -516, -515, -514, -512, -511, -510, -509, -508, -507, -505, -504, -503, -502, -501, -500, -498, -497, -496, -495, -494, -493, -491, -490, -489, -488, -487, -486, -484, -483, -482, -481, -480, -479, -477, -476, -475, -474, -473, -472, -470, -469, -468, -467, -466, -465, -463, -462, -461, -460, -459, -458, -456, -455, -454, -453, -452, -451, -449, -448, -447, -446, -445, -444, -442, -441, -440, -439, -438, -437, -435, -434, -433, -432, -431, -430, -428, -427, -426, -425, -424, -423, -421, -420, -419, -418, -417, -416, -414, -413, -412, -411, -410, -409, -407, -406, -405, -404, -403, -402, -400, -399, -398, -397, -396, -395, -393, -392, -391, -390, -389, -388, -386, -385, -384, -383, -382, -381, -379, -378, -377, -376, -375, -374, -372, -371, -370, -369, -368, -367, -365, -364, -363, -362, -361, -360, -358, -357, -356, -355, -354, -353, -351, -350, -349, -348, -347, -346, -344, -343, -342, -341, -340, -339, -337, -336, -335, -334, -333, -332, -330, -329, -328, -327, -326, -325, -323, -322, -321, -320, -319, -318, -316, -315, -314, -313, -312, -311, -309, -308, -307, -306, -305, -304, -302, -301, -300, -299, -298, -297, -295, -294, -293, -292, -291, -290, -288, -287, -286, -285, -284, -283, -281, -280, -279, -278, -277, -276, -274, -273, -272, -271, -270, -269, -267, -266, -265, -264, -263, -262, -260, -259, -258, -257, -256, -255, -253, -252, -251, -250, -249, -248, -246, -245, -244, -243, -242, -241, -239, -238, -237, -236, -235, -234, -232, -231, -230, -229, -228, -227, -225, -224, -223, -222, -221, -220, -218, -217, -216, -215, -214, -213, -211, -210, -209, -208, -207, -206, -204, -203, -202, -201, -200, -199, -197, -196, -195, -194, -193, -192, -190, -189, -188, -187, -186, -185, -183, -182, -181, -180, -179, -178, -176, -175, -174, -173, -172, -171, -169, -168, -167, -166, -165, -164, -162, -161, -160, -159, -158, -157, -155, -154, -153, -152, -151, -150, -148, -147, -146, -145, -144, -143, -141, -140, -139, -138, -137, -136, -134, -133, -132, -131, -130, -129, -127, -126, -125, -124, -123, -122, -120, -119, -118, -117, -116, -115, -113, -112, -111, -110, -109, -108, -106, -105, -104, -103, -102, -101, -99, -98, -97, -96, -95, -94, -92, -91, -90, -89, -88, -87, -85, -84, -83, -82, -81, -80, -78, -77, -76, -75, -74, -73, -71, -70, -69, -68, -67, -66, -64, -63, -62, -61, -60, -59, -57, -56, -55, -54, -53, -52, -50, -49, -48, -47, -46, -45, -43, -42, -41, -40, -39, -38, -36, -35, -34, -33, -32, -31, -29, -28, -27, -26, -25, -24, -22, -21, -20, -19, -18, -17, -15, -14, -13, -12, -11, -10, -8, -7, -6, -5, -4, -3, -1, 1, 2, 3, 4, 5, 7, 8, 9, 10, 11, 12, 14, 15, 16, 17, 18, 19, 21, 22, 23, 24, 25, 26, 28, 29, 30, 31, 32, 33, 35, 36, 37, 38, 39, 40, 42, 43, 44, 45, 46, 47, 49, 50, 51, 52, 53, 54, 56, 57, 58, 59, 60, 61, 63, 64, 65, 66, 67, 68, 70, 71, 72, 73, 74, 75, 77, 78, 79, 80, 81, 82, 84, 85, 86, 87, 88, 89, 91, 92, 93, 94, 95, 96, 98, 99, 100, 101, 102, 103, 105, 106, 107, 108, 109, 110, 112, 113, 114, 115, 116, 117, 119, 120, 121, 122, 123, 124, 126, 127, 128, 129, 130, 131, 133, 134, 135, 136, 137, 138, 140, 141, 142, 143, 144, 145, 147, 148, 149, 150, 151, 152, 154, 155, 156, 157, 158, 159, 161, 162, 163, 164, 165, 166, 168, 169, 170, 171, 172, 173, 175, 176, 177, 178, 179, 180, 182, 183, 184, 185, 186, 187, 189, 190, 191, 192, 193, 194, 196, 197, 198, 199, 200, 201, 203, 204, 205, 206, 207, 208, 210, 211, 212, 213, 214, 215, 217, 218, 219, 220, 221, 222, 224, 225, 226, 227, 228, 229, 231, 232, 233, 234, 235, 236, 238, 239, 240, 241, 242, 243, 245, 246, 247, 248, 249, 250, 252, 253, 254, 255, 256, 257, 259, 260, 261, 262, 263, 264, 266, 267, 268, 269, 270, 271, 273, 274, 275, 276, 277, 278, 280, 281, 282, 283, 284, 285, 287, 288, 289, 290, 291, 292, 294, 295, 296, 297, 298, 299, 301, 302, 303, 304, 305, 306, 308, 309, 310, 311, 312, 313, 315, 316, 317, 318, 319, 320, 322, 323, 324, 325, 326, 327, 329, 330, 331, 332, 333, 334, 336, 337, 338, 339, 340, 341, 343, 344, 345, 346, 347, 348, 350, 351, 352, 353, 354, 355, 357, 358, 359, 360, 361, 362, 364, 365, 366, 367, 368, 369, 371, 372, 373, 374, 375, 376, 378, 379, 380, 381, 382, 383, 385, 386, 387, 388, 389, 390, 392, 393, 394, 395, 396, 397, 399, 400, 401, 402, 403, 404, 406, 407, 408, 409, 410, 411, 413, 414, 415, 416, 417, 418, 420, 421, 422, 423, 424, 425, 427, 428, 429, 430, 431, 432, 434, 435, 436, 437, 438, 439, 441, 442, 443, 444, 445, 446, 448, 449, 450, 451, 452, 453, 455, 456, 457, 458, 459, 460, 462, 463, 464, 465, 466, 467, 469, 470, 471, 472, 473, 474, 476, 477, 478, 479, 480, 481, 483, 484, 485, 486, 487, 488, 490, 491, 492, 493, 494, 495, 497, 498, 499, 500, 501, 502, 504, 505, 506, 507, 508, 509, 511, 512, 513, 514, 515, 516, 518, 519, 520, 521, 522, 523, 525, 526, 527, 528, 529, 530, 532, 533, 534, 535, 536, 537, 539, 540, 541, 542, 543, 544, 546, 547, 548, 549, 550, 551, 553, 554, 555, 556, 557, 558, 560, 561, 562, 563, 564, 565, 567, 568, 569, 570, 571, 572, 574, 575, 576, 577, 578, 579, 581, 582, 583, 584, 585, 586, 588, 589, 590, 591, 592, 593, 595, 596, 597, 598, 599, 600, 602, 603, 604, 605, 606, 607, 609, 610, 611, 612, 613, 614, 616, 617, 618, 619, 620, 621, 623, 624, 625, 626, 627, 628, 630, 631, 632, 633, 634, 635, 637, 638, 639, 640, 641, 642, 644, 645, 646, 647, 648, 649, 651, 652, 653, 654, 655, 656, 658, 659, 660, 661, 662, 663, 665, 666, 667, 668, 669, 670, 672, 673, 674, 675, 676, 677, 679, 680, 681, 682, 683, 684, 686, 687, 688, 689, 690, 691, 693, 694, 695, 696, 697, 698, 700, 701, 702, 703, 704, 705, 707, 708, 709, 710, 711, 712, 714, 715, 716, 717, 718, 719, 721, 722, 723, 724, 725, 726, 728, 729, 730, 731, 732, 733, 735, 736, 737, 738, 739, 740, 742, 743, 744, 745, 746, 747, 749, 750, 751, 752, 753, 754, 756, 757, 758, 759, 760, 761, 763, 764, 765, 766, 767, 768, 770, 771, 772, 773, 774, 775, 777, 778, 779, 780, 781, 782, 784, 785, 786, 787, 788, 789, 791, 792, 793, 794, 795, 796, 798, 799, 800, 801, 802, 803, 805, 806, 807, 808, 809, 810, 812, 813, 814, 815, 816, 817, 819, 820, 821, 822, 823, 824, 826, 827, 828, 829, 830, 831, 833, 834, 835, 836, 837, 838, 840], [-840, -838, -837, -836, -835, -834, -833, -831, -830, -829, -828, -827, -826, -824, -823, -822, -821, -820, -819, -817, -816, -815, -814, -813, -812, -810, -809, -808, -807, -806, -805, -803, -802, -801, -800, -799, -798, -796, -795, -794, -793, -792, -791, -789, -788, -787, -786, -785, -784, -782, -781, -780, -779, -778, -777, -775, -774, -773, -772, -771, -770, -768, -767, -766, -765, -764, -763, -761, -760, -759, -758, -757, -756, -754, -753, -752, -751, -750, -749, -747, -746, -745, -744, -743, -742, -740, -739, -738, -737, -736, -735, -733, -732, -731, -730, -729, -728, -726, -725, -724, -723, -722, -721, -719, -718, -717, -716, -715, -714, -712, -711, -710, -709, -708, -707, -705, -704, -703, -702, -701, -700, -698, -697, -696, -695, -694, -693, -691, -690, -689, -688, -687, -686, -684, -683, -682, -681, -680, -679, -677, -676, -675, -674, -673, -672, -670, -669, -668, -667, -666, -665, -663, -662, -661, -660, -659, -658, -656, -655, -654, -653, -652, -651, -649, -648, -647, -646, -645, -644, -642, -641, -640, -639, -638, -637, -635, -634, -633, -632, -631, -630, -628, -627, -626, -625, -624, -623, -621, -620, -619, -618, -617, -616, -614, -613, -612, -611, -610, -609, -607, -606, -605, -604, -603, -602, -600, -599, -598, -597, -596, -595, -593, -592, -591, -590, -589, -588, -586, -585, -584, -583, -582, -581, -579, -578, -577, -576, -575, -574, -572, -571, -570, -569, -568, -567, -565, -564, -563, -562, -561, -560, -558, -557, -556, -555, -554, -553, -551, -550, -549, -548, -547, -546, -544, -543, -542, -541, -540, -539, -537, -536, -535, -534, -533, -532, -530, -529, -528, -527, -526, -525, -523, -522, -521, -520, -519, -518, -516, -515, -514, -513, -512, -511, -509, -508, -507, -506, -505, -504, -502, -501, -500, -499, -498, -497, -495, -494, -493, -492, -491, -490, -488, -487, -486, -485, -484, -483, -481, -480, -479, -478, -477, -476, -474, -473, -472, -471, -470, -469, -467, -466, -465, -464, -463, -462, -460, -459, -458, -457, -456, -455, -453, -452, -451, -450, -449, -448, -446, -445, -444, -443, -442, -441, -439, -438, -437, -436, -435, -434, -432, -431, -430, -429, -428, -427, -425, -424, -423, -422, -421, -420, -418, -417, -416, -415, -414, -413, -411, -410, -409, -408, -407, -406, -404, -403, -402, -401, -400, -399, -397, -396, -395, -394, -393, -392, -390, -389, -388, -387, -386, -385, -383, -382, -381, -380, -379, -378, -376, -375, -374, -373, -372, -371, -369, -368, -367, -366, -365, -364, -362, -361, -360, -359, -358, -357, -355, -354, -353, -352, -351, -350, -348, -347, -346, -345, -344, -343, -341, -340, -339, -338, -337, -336, -334, -333, -332, -331, -330, -329, -327, -326, -325, -324, -323, -322, -320, -319, -318, -317, -316, -315, -313, -312, -311, -310, -309, -308, -306, -305, -304, -303, -302, -301, -299, -298, -297, -296, -295, -294, -292, -291, -290, -289, -288, -287, -285, -284, -283, -282, -281, -280, -278, -277, -276, -275, -274, -273, -271, -270, -269, -268, -267, -266, -264, -263, -262, -261, -260, -259, -257, -256, -255, -254, -253, -252, -250, -249, -248, -247, -246, -245, -243, -242, -241, -240, -239, -238, -236, -235, -234, -233, -232, -231, -229, -228, -227, -226, -225, -224, -222, -221, -220, -219, -218, -217, -215, -214, -213, -212, -211, -210, -208, -207, -206, -205, -204, -203, -201, -200, -199, -198, -197, -196, -194, -193, -192, -191, -190, -189, -187, -186, -185, -184, -183, -182, -180, -179, -178, -177, -176, -175, -173, -172, -171, -170, -169, -168, -166, -165, -164, -163, -162, -161, -159, -158, -157, -156, -155, -154, -152, -151, -150, -149, -148, -147, -145, -144, -143, -142, -141, -140, -138, -137, -136, -135, -134, -133, -131, -130, -129, -128, -127, -126, -124, -123, -122, -121, -120, -119, -117, -116, -115, -114, -113, -112, -110, -109, -108, -107, -106, -105, -103, -102, -101, -100, -99, -98, -96, -95, -94, -93, -92, -91, -89, -88, -87, -86, -85, -84, -82, -81, -80, -79, -78, -77, -75, -74, -73, -72, -71, -70, -68, -67, -66, -65, -64, -63, -61, -60, -59, -58, -57, -56, -54, -53, -52, -51, -50, -49, -47, -46, -45, -44, -43, -42, -40, -39, -38, -37, -36, -35, -33, -32, -31, -30, -29, -28, -26, -25, -24, -23, -22, -21, -19, -18, -17, -16, -15, -14, -12, -11, -10, -9, -8, -7, -5, -4, -3, -2, -1, 1, 3, 4, 5, 6, 7, 8, 10, 11, 12, 13, 14, 15, 17, 18, 19, 20, 21, 22, 24, 25, 26, 27, 28, 29, 31, 32, 33, 34, 35, 36, 38, 39, 40, 41, 42, 43, 45, 46, 47, 48, 49, 50, 52, 53, 54, 55, 56, 57, 59, 60, 61, 62, 63, 64, 66, 67, 68, 69, 70, 71, 73, 74, 75, 76, 77, 78, 80, 81, 82, 83, 84, 85, 87, 88, 89, 90, 91, 92, 94, 95, 96, 97, 98, 99, 101, 102, 103, 104, 105, 106, 108, 109, 110, 111, 112, 113, 115, 116, 117, 118, 119, 120, 122, 123, 124, 125, 126, 127, 129, 130, 131, 132, 133, 134, 136, 137, 138, 139, 140, 141, 143, 144, 145, 146, 147, 148, 150, 151, 152, 153, 154, 155, 157, 158, 159, 160, 161, 162, 164, 165, 166, 167, 168, 169, 171, 172, 173, 174, 175, 176, 178, 179, 180, 181, 182, 183, 185, 186, 187, 188, 189, 190, 192, 193, 194, 195, 196, 197, 199, 200, 201, 202, 203, 204, 206, 207, 208, 209, 210, 211, 213, 214, 215, 216, 217, 218, 220, 221, 222, 223, 224, 225, 227, 228, 229, 230, 231, 232, 234, 235, 236, 237, 238, 239, 241, 242, 243, 244, 245, 246, 248, 249, 250, 251, 252, 253, 255, 256, 257, 258, 259, 260, 262, 263, 264, 265, 266, 267, 269, 270, 271, 272, 273, 274, 276, 277, 278, 279, 280, 281, 283, 284, 285, 286, 287, 288, 290, 291, 292, 293, 294, 295, 297, 298, 299, 300, 301, 302, 304, 305, 306, 307, 308, 309, 311, 312, 313, 314, 315, 316, 318, 319, 320, 321, 322, 323, 325, 326, 327, 328, 329, 330, 332, 333, 334, 335, 336, 337, 339, 340, 341, 342, 343, 344, 346, 347, 348, 349, 350, 351, 353, 354, 355, 356, 357, 358, 360, 361, 362, 363, 364, 365, 367, 368, 369, 370, 371, 372, 374, 375, 376, 377, 378, 379, 381, 382, 383, 384, 385, 386, 388, 389, 390, 391, 392, 393, 395, 396, 397, 398, 399, 400, 402, 403, 404, 405, 406, 407, 409, 410, 411, 412, 413, 414, 416, 417, 418, 419, 420, 421, 423, 424, 425, 426, 427, 428, 430, 431, 432, 433, 434, 435, 437, 438, 439, 440, 441, 442, 444, 445, 446, 447, 448, 449, 451, 452, 453, 454, 455, 456, 458, 459, 460, 461, 462, 463, 465, 466, 467, 468, 469, 470, 472, 473, 474, 475, 476, 477, 479, 480, 481, 482, 483, 484, 486, 487, 488, 489, 490, 491, 493, 494, 495, 496, 497, 498, 500, 501, 502, 503, 504, 505, 507, 508, 509, 510, 511, 512, 514, 515, 516, 517, 518, 519, 521, 522, 523, 524, 525, 526, 528, 529, 530, 531, 532, 533, 535, 536, 537, 538, 539, 540, 542, 543, 544, 545, 546, 547, 549, 550, 551, 552, 553, 554, 556, 557, 558, 559, 560, 561, 563, 564, 565, 566, 567, 568, 570, 571, 572, 573, 574, 575, 577, 578, 579, 580, 581, 582, 584, 585, 586, 587, 588, 589, 591, 592, 593, 594, 595, 596, 598, 599, 600, 601, 602, 603, 605, 606, 607, 608, 609, 610, 612, 613, 614, 615, 616, 617, 619, 620, 621, 622, 623, 624, 626, 627, 628, 629, 630, 631, 633, 634, 635, 636, 637, 638, 640, 641, 642, 643, 644, 645, 647, 648, 649, 650, 651, 652, 654, 655, 656, 657, 658, 659, 661, 662, 663, 664, 665, 666, 668, 669, 670, 671, 672, 673, 675, 676, 677, 678, 679, 680, 682, 683, 684, 685, 686, 687, 689, 690, 691, 692, 693, 694, 696, 697, 698, 699, 700, 701, 703, 704, 705, 706, 707, 708, 710, 711, 712, 713, 714, 715, 717, 718, 719, 720, 721, 722, 724, 725, 726, 727, 728, 729, 731, 732, 733, 734, 735, 736, 738, 739, 740, 741, 742, 743, 745, 746, 747, 748, 749, 750, 752, 753, 754, 755, 756, 757, 759, 760, 761, 762, 763, 764, 766, 767, 768, 769, 770, 771, 773, 774, 775, 776, 777, 778, 780, 781, 782, 783, 784, 785, 787, 788, 789, 790, 791, 792, 794, 795, 796, 797, 798, 799, 801, 802, 803, 804, 805, 806, 808, 809, 810, 811, 812, 813, 815, 816, 817, 818, 819, 820, 822, 823, 824, 825, 826, 827, 829, 830, 831, 832, 833, 834, 836, 837, 838, 839, 840], [-840, -839, -838, -837, -835, -834, -833, -832, -831, -830, -828, -827, -826, -825, -824, -823, -821, -820, -819, -818, -817, -816, -814, -813, -812, -811, -810, -809, -807, -806, -805, -804, -803, -802, -800, -799, -798, -797, -796, -795, -793, -792, -791, -790, -789, -788, -786, -785, -784, -783, -782, -781, -779, -778, -777, -776, -775, -774, -772, -771, -770, -769, -768, -767, -765, -764, -763, -762, -761, -760, -758, -757, -756, -755, -754, -753, -751, -750, -749, -748, -747, -746, -744, -743, -742, -741, -740, -739, -737, -736, -735, -734, -733, -732, -730, -729, -728, -727, -726, -725, -723, -722, -721, -720, -719, -718, -716, -715, -714, -713, -712, -711, -709, -708, -707, -706, -705, -704, -702, -701, -700, -699, -698, -697, -695, -694, -693, -692, -691, -690, -688, -687, -686, -685, -684, -683, -681, -680, -679, -678, -677, -676, -674, -673, -672, -671, -670, -669, -667, -666, -665, -664, -663, -662, -660, -659, -658, -657, -656, -655, -653, -652, -651, -650, -649, -648, -646, -645, -644, -643, -642, -641, -639, -638, -637, -636, -635, -634, -632, -631, -630, -629, -628, -627, -625, -624, -623, -622, -621, -620, -618, -617, -616, -615, -614, -613, -611, -610, -609, -608, -607, -606, -604, -603, -602, -601, -600, -599, -597, -596, -595, -594, -593, -592, -590, -589, -588, -587, -586, -585, -583, -582, -581, -580, -579, -578, -576, -575, -574, -573, -572, -571, -569, -568, -567, -566, -565, -564, -562, -561, -560, -559, -558, -557, -555, -554, -553, -552, -551, -550, -548, -547, -546, -545, -544, -543, -541, -540, -539, -538, -537, -536, -534, -533, -532, -531, -530, -529, -527, -526, -525, -524, -523, -522, -520, -519, -518, -517, -516, -515, -513, -512, -511, -510, -509, -508, -506, -505, -504, -503, -502, -501, -499, -498, -497, -496, -495, -494, -492, -491, -490, -489, -488, -487, -485, -484, -483, -482, -481, -480, -478, -477, -476, -475, -474, -473, -471, -470, -469, -468, -467, -466, -464, -463, -462, -461, -460, -459, -457, -456, -455, -454, -453, -452, -450, -449, -448, -447, -446, -445, -443, -442, -441, -440, -439, -438, -436, -435, -434, -433, -432, -431, -429, -428, -427, -426, -425, -424, -422, -421, -420, -419, -418, -417, -415, -414, -413, -412, -411, -410, -408, -407, -406, -405, -404, -403, -401, -400, -399, -398, -397, -396, -394, -393, -392, -391, -390, -389, -387, -386, -385, -384, -383, -382, -380, -379, -378, -377, -376, -375, -373, -372, -371, -370, -369, -368, -366, -365, -364, -363, -362, -361, -359, -358, -357, -356, -355, -354, -352, -351, -350, -349, -348, -347, -345, -344, -343, -342, -341, -340, -338, -337, -336, -335, -334, -333, -331, -330, -329, -328, -327, -326, -324, -323, -322, -321, -320, -319, -317, -316, -315, -314, -313, -312, -310, -309, -308, -307, -306, -305, -303, -302, -301, -300, -299, -298, -296, -295, -294, -293, -292, -291, -289, -288, -287, -286, -285, -284, -282, -281, -280, -279, -278, -277, -275, -274, -273, -272, -271, -270, -268, -267, -266, -265, -264, -263, -261, -260, -259, -258, -257, -256, -254, -253, -252, -251, -250, -249, -247, -246, -245, -244, -243, -242, -240, -239, -238, -237, -236, -235, -233, -232, -231, -230, -229, -228, -226, -225, -224, -223, -222, -221, -219, -218, -217, -216, -215, -214, -212, -211, -210, -209, -208, -207, -205, -204, -203, -202, -201, -200, -198, -197, -196, -195, -194, -193, -191, -190, -189, -188, -187, -186, -184, -183, -182, -181, -180, -179, -177, -176, -175, -174, -173, -172, -170, -169, -168, -167, -166, -165, -163, -162, -161, -160, -159, -158, -156, -155, -154, -153, -152, -151, -149, -148, -147, -146, -145, -144, -142, -141, -140, -139, -138, -137, -135, -134, -133, -132, -131, -130, -128, -127, -126, -125, -124, -123, -121, -120, -119, -118, -117, -116, -114, -113, -112, -111, -110, -109, -107, -106, -105, -104, -103, -102, -100, -99, -98, -97, -96, -95, -93, -92, -91, -90, -89, -88, -86, -85, -84, -83, -82, -81, -79, -78, -77, -76, -75, -74, -72, -71, -70, -69, -68, -67, -65, -64, -63, -62, -61, -60, -58, -57, -56, -55, -54, -53, -51, -50, -49, -48, -47, -46, -44, -43, -42, -41, -40, -39, -37, -36, -35, -34, -33, -32, -30, -29, -28, -27, -26, -25, -23, -22, -21, -20, -19, -18, -16, -15, -14, -13, -12, -11, -9, -8, -7, -6, -5, -4, -2, -1, 1, 2, 3, 4, 6, 7, 8, 9, 10, 11, 13, 14, 15, 16, 17, 18, 20, 21, 22, 23, 24, 25, 27, 28, 29, 30, 31, 32, 34, 35, 36, 37, 38, 39, 41, 42, 43, 44, 45, 46, 48, 49, 50, 51, 52, 53, 55, 56, 57, 58, 59, 60, 62, 63, 64, 65, 66, 67, 69, 70, 71, 72, 73, 74, 76, 77, 78, 79, 80, 81, 83, 84, 85, 86, 87, 88, 90, 91, 92, 93, 94, 95, 97, 98, 99, 100, 101, 102, 104, 105, 106, 107, 108, 109, 111, 112, 113, 114, 115, 116, 118, 119, 120, 121, 122, 123, 125, 126, 127, 128, 129, 130, 132, 133, 134, 135, 136, 137, 139, 140, 141, 142, 143, 144, 146, 147, 148, 149, 150, 151, 153, 154, 155, 156, 157, 158, 160, 161, 162, 163, 164, 165, 167, 168, 169, 170, 171, 172, 174, 175, 176, 177, 178, 179, 181, 182, 183, 184, 185, 186, 188, 189, 190, 191, 192, 193, 195, 196, 197, 198, 199, 200, 202, 203, 204, 205, 206, 207, 209, 210, 211, 212, 213, 214, 216, 217, 218, 219, 220, 221, 223, 224, 225, 226, 227, 228, 230, 231, 232, 233, 234, 235, 237, 238, 239, 240, 241, 242, 244, 245, 246, 247, 248, 249, 251, 252, 253, 254, 255, 256, 258, 259, 260, 261, 262, 263, 265, 266, 267, 268, 269, 270, 272, 273, 274, 275, 276, 277, 279, 280, 281, 282, 283, 284, 286, 287, 288, 289, 290, 291, 293, 294, 295, 296, 297, 298, 300, 301, 302, 303, 304, 305, 307, 308, 309, 310, 311, 312, 314, 315, 316, 317, 318, 319, 321, 322, 323, 324, 325, 326, 328, 329, 330, 331, 332, 333, 335, 336, 337, 338, 339, 340, 342, 343, 344, 345, 346, 347, 349, 350, 351, 352, 353, 354, 356, 357, 358, 359, 360, 361, 363, 364, 365, 366, 367, 368, 370, 371, 372, 373, 374, 375, 377, 378, 379, 380, 381, 382, 384, 385, 386, 387, 388, 389, 391, 392, 393, 394, 395, 396, 398, 399, 400, 401, 402, 403, 405, 406, 407, 408, 409, 410, 412, 413, 414, 415, 416, 417, 419, 420, 421, 422, 423, 424, 426, 427, 428, 429, 430, 431, 433, 434, 435, 436, 437, 438, 440, 441, 442, 443, 444, 445, 447, 448, 449, 450, 451, 452, 454, 455, 456, 457, 458, 459, 461, 462, 463, 464, 465, 466, 468, 469, 470, 471, 472, 473, 475, 476, 477, 478, 479, 480, 482, 483, 484, 485, 486, 487, 489, 490, 491, 492, 493, 494, 496, 497, 498, 499, 500, 501, 503, 504, 505, 506, 507, 508, 510, 511, 512, 513, 514, 515, 517, 518, 519, 520, 521, 522, 524, 525, 526, 527, 528, 529, 531, 532, 533, 534, 535, 536, 538, 539, 540, 541, 542, 543, 545, 546, 547, 548, 549, 550, 552, 553, 554, 555, 556, 557, 559, 560, 561, 562, 563, 564, 566, 567, 568, 569, 570, 571, 573, 574, 575, 576, 577, 578, 580, 581, 582, 583, 584, 585, 587, 588, 589, 590, 591, 592, 594, 595, 596, 597, 598, 599, 601, 602, 603, 604, 605, 606, 608, 609, 610, 611, 612, 613, 615, 616, 617, 618, 619, 620, 622, 623, 624, 625, 626, 627, 629, 630, 631, 632, 633, 634, 636, 637, 638, 639, 640, 641, 643, 644, 645, 646, 647, 648, 650, 651, 652, 653, 654, 655, 657, 658, 659, 660, 661, 662, 664, 665, 666, 667, 668, 669, 671, 672, 673, 674, 675, 676, 678, 679, 680, 681, 682, 683, 685, 686, 687, 688, 689, 690, 692, 693, 694, 695, 696, 697, 699, 700, 701, 702, 703, 704, 706, 707, 708, 709, 710, 711, 713, 714, 715, 716, 717, 718, 720, 721, 722, 723, 724, 725, 727, 728, 729, 730, 731, 732, 734, 735, 736, 737, 738, 739, 741, 742, 743, 744, 745, 746, 748, 749, 750, 751, 752, 753, 755, 756, 757, 758, 759, 760, 762, 763, 764, 765, 766, 767, 769, 770, 771, 772, 773, 774, 776, 777, 778, 779, 780, 781, 783, 784, 785, 786, 787, 788, 790, 791, 792, 793, 794, 795, 797, 798, 799, 800, 801, 802, 804, 805, 806, 807, 808, 809, 811, 812, 813, 814, 815, 816, 818, 819, 820, 821, 822, 823, 825, 826, 827, 828, 829, 830, 832, 833, 834, 835, 836, 837, 839, 840], [-840, -839, -838, -837, -836, -835, -833, -832, -831, -830, -829, -828, -826, -825, -824, -823, -822, -821, -819, -818, -817, -816, -815, -814, -812, -811, -810, -809, -808, -807, -805, -804, -803, -802, -801, -800, -798, -797, -796, -795, -794, -793, -791, -790, -789, -788, -787, -786, -784, -783, -782, -781, -780, -779, -777, -776, -775, -774, -773, -772, -770, -769, -768, -767, -766, -765, -763, -762, -761, -760, -759, -758, -756, -755, -754, -753, -752, -751, -749, -748, -747, -746, -745, -744, -742, -741, -740, -739, -738, -737, -735, -734, -733, -732, -731, -730, -728, -727, -726, -725, -724, -723, -721, -720, -719, -718, -717, -716, -714, -713, -712, -711, -710, -709, -707, -706, -705, -704, -703, -702, -700, -699, -698, -697, -696, -695, -693, -692, -691, -690, -689, -688, -686, -685, -684, -683, -682, -681, -679, -678, -677, -676, -675, -674, -672, -671, -670, -669, -668, -667, -665, -664, -663, -662, -661, -660, -658, -657, -656, -655, -654, -653, -651, -650, -649, -648, -647, -646, -644, -643, -642, -641, -640, -639, -637, -636, -635, -634, -633, -632, -630, -629, -628, -627, -626, -625, -623, -622, -621, -620, -619, -618, -616, -615, -614, -613, -612, -611, -609, -608, -607, -606, -605, -604, -602, -601, -600, -599, -598, -597, -595, -594, -593, -592, -591, -590, -588, -587, -586, -585, -584, -583, -581, -580, -579, -578, -577, -576, -574, -573, -572, -571, -570, -569, -567, -566, -565, -564, -563, -562, -560, -559, -558, -557, -556, -555, -553, -552, -551, -550, -549, -548, -546, -545, -544, -543, -542, -541, -539, -538, -537, -536, -535, -534, -532, -531, -530, -529, -528, -527, -525, -524, -523, -522, -521, -520, -518, -517, -516, -515, -514, -513, -511, -510, -509, -508, -507, -506, -504, -503, -502, -501, -500, -499, -497, -496, -495, -494, -493, -492, -490, -489, -488, -487, -486, -485, -483, -482, -481, -480, -479, -478, -476, -475, -474, -473, -472, -471, -469, -468, -467, -466, -465, -464, -462, -461, -460, -459, -458, -457, -455, -454, -453, -452, -451, -450, -448, -447, -446, -445, -444, -443, -441, -440, -439, -438, -437, -436, -434, -433, -432, -431, -430, -429, -427, -426, -425, -424, -423, -422, -420, -419, -418, -417, -416, -415, -413, -412, -411, -410, -409, -408, -406, -405, -404, -403, -402, -401, -399, -398, -397, -396, -395, -394, -392, -391, -390, -389, -388, -387, -385, -384, -383, -382, -381, -380, -378, -377, -376, -375, -374, -373, -371, -370, -369, -368, -367, -366, -364, -363, -362, -361, -360, -359, -357, -356, -355, -354, -353, -352, -350, -349, -348, -347, -346, -345, -343, -342, -341, -340, -339, -338, -336, -335, -334, -333, -332, -331, -329, -328, -327, -326, -325, -324, -322, -321, -320, -319, -318, -317, -315, -314, -313, -312, -311, -310, -308, -307, -306, -305, -304, -303, -301, -300, -299, -298, -297, -296, -294, -293, -292, -291, -290, -289, -287, -286, -285, -284, -283, -282, -280, -279, -278, -277, -276, -275, -273, -272, -271, -270, -269, -268, -266, -265, -264, -263, -262, -261, -259, -258, -257, -256, -255, -254, -252, -251, -250, -249, -248, -247, -245, -244, -243, -242, -241, -240, -238, -237, -236, -235, -234, -233, -231, -230, -229, -228, -227, -226, -224, -223, -222, -221, -220, -219, -217, -216, -215, -214, -213, -212, -210, -209, -208, -207, -206, -205, -203, -202, -201, -200, -199, -198, -196, -195, -194, -193, -192, -191, -189, -188, -187, -186, -185, -184, -182, -181, -180, -179, -178, -177, -175, -174, -173, -172, -171, -170, -168, -167, -166, -165, -164, -163, -161, -160, -159, -158, -157, -156, -154, -153, -152, -151, -150, -149, -147, -146, -145, -144, -143, -142, -140, -139, -138, -137, -136, -135, -133, -132, -131, -130, -129, -128, -126, -125, -124, -123, -122, -121, -119, -118, -117, -116, -115, -114, -112, -111, -110, -109, -108, -107, -105, -104, -103, -102, -101, -100, -98, -97, -96, -95, -94, -93, -91, -90, -89, -88, -87, -86, -84, -83, -82, -81, -80, -79, -77, -76, -75, -74, -73, -72, -70, -69, -68, -67, -66, -65, -63, -62, -61, -60, -59, -58, -56, -55, -54, -53, -52, -51, -49, -48, -47, -46, -45, -44, -42, -41, -40, -39, -38, -37, -35, -34, -33, -32, -31, -30, -28, -27, -26, -25, -24, -23, -21, -20, -19, -18, -17, -16, -14, -13, -12, -11, -10, -9, -7, -6, -5, -4, -3, -2, 1, 2, 3, 4, 5, 6, 8, 9, 10, 11, 12, 13, 15, 16, 17, 18, 19, 20, 22, 23, 24, 25, 26, 27, 29, 30, 31, 32, 33, 34, 36, 37, 38, 39, 40, 41, 43, 44, 45, 46, 47, 48, 50, 51, 52, 53, 54, 55, 57, 58, 59, 60, 61, 62, 64, 65, 66, 67, 68, 69, 71, 72, 73, 74, 75, 76, 78, 79, 80, 81, 82, 83, 85, 86, 87, 88, 89, 90, 92, 93, 94, 95, 96, 97, 99, 100, 101, 102, 103, 104, 106, 107, 108, 109, 110, 111, 113, 114, 115, 116, 117, 118, 120, 121, 122, 123, 124, 125, 127, 128, 129, 130, 131, 132, 134, 135, 136, 137, 138, 139, 141, 142, 143, 144, 145, 146, 148, 149, 150, 151, 152, 153, 155, 156, 157, 158, 159, 160, 162, 163, 164, 165, 166, 167, 169, 170, 171, 172, 173, 174, 176, 177, 178, 179, 180, 181, 183, 184, 185, 186, 187, 188, 190, 191, 192, 193, 194, 195, 197, 198, 199, 200, 201, 202, 204, 205, 206, 207, 208, 209, 211, 212, 213, 214, 215, 216, 218, 219, 220, 221, 222, 223, 225, 226, 227, 228, 229, 230, 232, 233, 234, 235, 236, 237, 239, 240, 241, 242, 243, 244, 246, 247, 248, 249, 250, 251, 253, 254, 255, 256, 257, 258, 260, 261, 262, 263, 264, 265, 267, 268, 269, 270, 271, 272, 274, 275, 276, 277, 278, 279, 281, 282, 283, 284, 285, 286, 288, 289, 290, 291, 292, 293, 295, 296, 297, 298, 299, 300, 302, 303, 304, 305, 306, 307, 309, 310, 311, 312, 313, 314, 316, 317, 318, 319, 320, 321, 323, 324, 325, 326, 327, 328, 330, 331, 332, 333, 334, 335, 337, 338, 339, 340, 341, 342, 344, 345, 346, 347, 348, 349, 351, 352, 353, 354, 355, 356, 358, 359, 360, 361, 362, 363, 365, 366, 367, 368, 369, 370, 372, 373, 374, 375, 376, 377, 379, 380, 381, 382, 383, 384, 386, 387, 388, 389, 390, 391, 393, 394, 395, 396, 397, 398, 400, 401, 402, 403, 404, 405, 407, 408, 409, 410, 411, 412, 414, 415, 416, 417, 418, 419, 421, 422, 423, 424, 425, 426, 428, 429, 430, 431, 432, 433, 435, 436, 437, 438, 439, 440, 442, 443, 444, 445, 446, 447, 449, 450, 451, 452, 453, 454, 456, 457, 458, 459, 460, 461, 463, 464, 465, 466, 467, 468, 470, 471, 472, 473, 474, 475, 477, 478, 479, 480, 481, 482, 484, 485, 486, 487, 488, 489, 491, 492, 493, 494, 495, 496, 498, 499, 500, 501, 502, 503, 505, 506, 507, 508, 509, 510, 512, 513, 514, 515, 516, 517, 519, 520, 521, 522, 523, 524, 526, 527, 528, 529, 530, 531, 533, 534, 535, 536, 537, 538, 540, 541, 542, 543, 544, 545, 547, 548, 549, 550, 551, 552, 554, 555, 556, 557, 558, 559, 561, 562, 563, 564, 565, 566, 568, 569, 570, 571, 572, 573, 575, 576, 577, 578, 579, 580, 582, 583, 584, 585, 586, 587, 589, 590, 591, 592, 593, 594, 596, 597, 598, 599, 600, 601, 603, 604, 605, 606, 607, 608, 610, 611, 612, 613, 614, 615, 617, 618, 619, 620, 621, 622, 624, 625, 626, 627, 628, 629, 631, 632, 633, 634, 635, 636, 638, 639, 640, 641, 642, 643, 645, 646, 647, 648, 649, 650, 652, 653, 654, 655, 656, 657, 659, 660, 661, 662, 663, 664, 666, 667, 668, 669, 670, 671, 673, 674, 675, 676, 677, 678, 680, 681, 682, 683, 684, 685, 687, 688, 689, 690, 691, 692, 694, 695, 696, 697, 698, 699, 701, 702, 703, 704, 705, 706, 708, 709, 710, 711, 712, 713, 715, 716, 717, 718, 719, 720, 722, 723, 724, 725, 726, 727, 729, 730, 731, 732, 733, 734, 736, 737, 738, 739, 740, 741, 743, 744, 745, 746, 747, 748, 750, 751, 752, 753, 754, 755, 757, 758, 759, 760, 761, 762, 764, 765, 766, 767, 768, 769, 771, 772, 773, 774, 775, 776, 778, 779, 780, 781, 782, 783, 785, 786, 787, 788, 789, 790, 792, 793, 794, 795, 796, 797, 799, 800, 801, 802, 803, 804, 806, 807, 808, 809, 810, 811, 813, 814, 815, 816, 817, 818, 820, 821, 822, 823, 824, 825, 827, 828, 829, 830, 831, 832, 834, 835, 836, 837, 838, 839], [-840, -839, -837, -836, -835, -834, -833, -832, -830, -829, -828, -827, -826, -825, -823, -822, -821, -820, -819, -818, -816, -815, -814, -813, -812, -811, -809, -808, -807, -806, -805, -804, -802, -801, -800, -799, -798, -797, -795, -794, -793, -792, -791, -790, -788, -787, -786, -785, -784, -783, -781, -780, -779, -778, -777, -776, -774, -773, -772, -771, -770, -769, -767, -766, -765, -764, -763, -762, -760, -759, -758, -757, -756, -755, -753, -752, -751, -750, -749, -748, -746, -745, -744, -743, -742, -741, -739, -738, -737, -736, -735, -734, -732, -731, -730, -729, -728, -727, -725, -724, -723, -722, -721, -720, -718, -717, -716, -715, -714, -713, -711, -710, -709, -708, -707, -706, -704, -703, -702, -701, -700, -699, -697, -696, -695, -694, -693, -692, -690, -689, -688, -687, -686, -685, -683, -682, -681, -680, -679, -678, -676, -675, -674, -673, -672, -671, -669, -668, -667, -666, -665, -664, -662, -661, -660, -659, -658, -657, -655, -654, -653, -652, -651, -650, -648, -647, -646, -645, -644, -643, -641, -640, -639, -638, -637, -636, -634, -633, -632, -631, -630, -629, -627, -626, -625, -624, -623, -622, -620, -619, -618, -617, -616, -615, -613, -612, -611, -610, -609, -608, -606, -605, -604, -603, -602, -601, -599, -598, -597, -596, -595, -594, -592, -591, -590, -589, -588, -587, -585, -584, -583, -582, -581, -580, -578, -577, -576, -575, -574, -573, -571, -570, -569, -568, -567, -566, -564, -563, -562, -561, -560, -559, -557, -556, -555, -554, -553, -552, -550, -549, -548, -547, -546, -545, -543, -542, -541, -540, -539, -538, -536, -535, -534, -533, -532, -531, -529, -528, -527, -526, -525, -524, -522, -521, -520, -519, -518, -517, -515, -514, -513, -512, -511, -510, -508, -507, -506, -505, -504, -503, -501, -500, -499, -498, -497, -496, -494, -493, -492, -491, -490, -489, -487, -486, -485, -484, -483, -482, -480, -479, -478, -477, -476, -475, -473, -472, -471, -470, -469, -468, -466, -465, -464, -463, -462, -461, -459, -458, -457, -456, -455, -454, -452, -451, -450, -449, -448, -447, -445, -444, -443, -442, -441, -440, -438, -437, -436, -435, -434, -433, -431, -430, -429, -428, -427, -426, -424, -423, -422, -421, -420, -419, -417, -416, -415, -414, -413, -412, -410, -409, -408, -407, -406, -405, -403, -402, -401, -400, -399, -398, -396, -395, -394, -393, -392, -391, -389, -388, -387, -386, -385, -384, -382, -381, -380, -379, -378, -377, -375, -374, -373, -372, -371, -370, -368, -367, -366, -365, -364, -363, -361, -360, -359, -358, -357, -356, -354, -353, -352, -351, -350, -349, -347, -346, -345, -344, -343, -342, -340, -339, -338, -337, -336, -335, -333, -332, -331, -330, -329, -328, -326, -325, -324, -323, -322, -321, -319, -318, -317, -316, -315, -314, -312, -311, -310, -309, -308, -307, -305, -304, -303, -302, -301, -300, -298, -297, -296, -295, -294, -293, -291, -290, -289, -288, -287, -286, -284, -283, -282, -281, -280, -279, -277, -276, -275, -274, -273, -272, -270, -269, -268, -267, -266, -265, -263, -262, -261, -260, -259, -258, -256, -255, -254, -253, -252, -251, -249, -248, -247, -246, -245, -244, -242, -241, -240, -239, -238, -237, -235, -234, -233, -232, -231, -230, -228, -227, -226, -225, -224, -223, -221, -220, -219, -218, -217, -216, -214, -213, -212, -211, -210, -209, -207, -206, -205, -204, -203, -202, -200, -199, -198, -197, -196, -195, -193, -192, -191, -190, -189, -188, -186, -185, -184, -183, -182, -181, -179, -178, -177, -176, -175, -174, -172, -171, -170, -169, -168, -167, -165, -164, -163, -162, -161, -160, -158, -157, -156, -155, -154, -153, -151, -150, -149, -148, -147, -146, -144, -143, -142, -141, -140, -139, -137, -136, -135, -134, -133, -132, -130, -129, -128, -127, -126, -125, -123, -122, -121, -120, -119, -118, -116, -115, -114, -113, -112, -111, -109, -108, -107, -106, -105, -104, -102, -101, -100, -99, -98, -97, -95, -94, -93, -92, -91, -90, -88, -87, -86, -85, -84, -83, -81, -80, -79, -78, -77, -76, -74, -73, -72, -71, -70, -69, -67, -66, -65, -64, -63, -62, -60, -59, -58, -57, -56, -55, -53, -52, -51, -50, -49, -48, -46, -45, -44, -43, -42, -41, -39, -38, -37, -36, -35, -34, -32, -31, -30, -29, -28, -27, -25, -24, -23, -22, -21, -20, -18, -17, -16, -15, -14, -13, -11, -10, -9, -8, -7, -6, -4, -3, -2, -1, 1, 2, 4, 5, 6, 7, 8, 9, 11, 12, 13, 14, 15, 16, 18, 19, 20, 21, 22, 23, 25, 26, 27, 28, 29, 30, 32, 33, 34, 35, 36, 37, 39, 40, 41, 42, 43, 44, 46, 47, 48, 49, 50, 51, 53, 54, 55, 56, 57, 58, 60, 61, 62, 63, 64, 65, 67, 68, 69, 70, 71, 72, 74, 75, 76, 77, 78, 79, 81, 82, 83, 84, 85, 86, 88, 89, 90, 91, 92, 93, 95, 96, 97, 98, 99, 100, 102, 103, 104, 105, 106, 107, 109, 110, 111, 112, 113, 114, 116, 117, 118, 119, 120, 121, 123, 124, 125, 126, 127, 128, 130, 131, 132, 133, 134, 135, 137, 138, 139, 140, 141, 142, 144, 145, 146, 147, 148, 149, 151, 152, 153, 154, 155, 156, 158, 159, 160, 161, 162, 163, 165, 166, 167, 168, 169, 170, 172, 173, 174, 175, 176, 177, 179, 180, 181, 182, 183, 184, 186, 187, 188, 189, 190, 191, 193, 194, 195, 196, 197, 198, 200, 201, 202, 203, 204, 205, 207, 208, 209, 210, 211, 212, 214, 215, 216, 217, 218, 219, 221, 222, 223, 224, 225, 226, 228, 229, 230, 231, 232, 233, 235, 236, 237, 238, 239, 240, 242, 243, 244, 245, 246, 247, 249, 250, 251, 252, 253, 254, 256, 257, 258, 259, 260, 261, 263, 264, 265, 266, 267, 268, 270, 271, 272, 273, 274, 275, 277, 278, 279, 280, 281, 282, 284, 285, 286, 287, 288, 289, 291, 292, 293, 294, 295, 296, 298, 299, 300, 301, 302, 303, 305, 306, 307, 308, 309, 310, 312, 313, 314, 315, 316, 317, 319, 320, 321, 322, 323, 324, 326, 327, 328, 329, 330, 331, 333, 334, 335, 336, 337, 338, 340, 341, 342, 343, 344, 345, 347, 348, 349, 350, 351, 352, 354, 355, 356, 357, 358, 359, 361, 362, 363, 364, 365, 366, 368, 369, 370, 371, 372, 373, 375, 376, 377, 378, 379, 380, 382, 383, 384, 385, 386, 387, 389, 390, 391, 392, 393, 394, 396, 397, 398, 399, 400, 401, 403, 404, 405, 406, 407, 408, 410, 411, 412, 413, 414, 415, 417, 418, 419, 420, 421, 422, 424, 425, 426, 427, 428, 429, 431, 432, 433, 434, 435, 436, 438, 439, 440, 441, 442, 443, 445, 446, 447, 448, 449, 450, 452, 453, 454, 455, 456, 457, 459, 460, 461, 462, 463, 464, 466, 467, 468, 469, 470, 471, 473, 474, 475, 476, 477, 478, 480, 481, 482, 483, 484, 485, 487, 488, 489, 490, 491, 492, 494, 495, 496, 497, 498, 499, 501, 502, 503, 504, 505, 506, 508, 509, 510, 511, 512, 513, 515, 516, 517, 518, 519, 520, 522, 523, 524, 525, 526, 527, 529, 530, 531, 532, 533, 534, 536, 537, 538, 539, 540, 541, 543, 544, 545, 546, 547, 548, 550, 551, 552, 553, 554, 555, 557, 558, 559, 560, 561, 562, 564, 565, 566, 567, 568, 569, 571, 572, 573, 574, 575, 576, 578, 579, 580, 581, 582, 583, 585, 586, 587, 588, 589, 590, 592, 593, 594, 595, 596, 597, 599, 600, 601, 602, 603, 604, 606, 607, 608, 609, 610, 611, 613, 614, 615, 616, 617, 618, 620, 621, 622, 623, 624, 625, 627, 628, 629, 630, 631, 632, 634, 635, 636, 637, 638, 639, 641, 642, 643, 644, 645, 646, 648, 649, 650, 651, 652, 653, 655, 656, 657, 658, 659, 660, 662, 663, 664, 665, 666, 667, 669, 670, 671, 672, 673, 674, 676, 677, 678, 679, 680, 681, 683, 684, 685, 686, 687, 688, 690, 691, 692, 693, 694, 695, 697, 698, 699, 700, 701, 702, 704, 705, 706, 707, 708, 709, 711, 712, 713, 714, 715, 716, 718, 719, 720, 721, 722, 723, 725, 726, 727, 728, 729, 730, 732, 733, 734, 735, 736, 737, 739, 740, 741, 742, 743, 744, 746, 747, 748, 749, 750, 751, 753, 754, 755, 756, 757, 758, 760, 761, 762, 763, 764, 765, 767, 768, 769, 770, 771, 772, 774, 775, 776, 777, 778, 779, 781, 782, 783, 784, 785, 786, 788, 789, 790, 791, 792, 793, 795, 796, 797, 798, 799, 800, 802, 803, 804, 805, 806, 807, 809, 810, 811, 812, 813, 814, 816, 817, 818, 819, 820, 821, 823, 824, 825, 826, 827, 828, 830, 831, 832, 833, 834, 835, 837, 838, 839, 840])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>out_buf_size</value></param>
<param><key>value</key><value>65000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>(1440*2)/8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_carriers</value></param>
<param><key>value</key><value>((-840, -833, -826, -819, -812, -805, -798, -791, -784, -777, -770, -763, -756, -749, -742, -735, -728, -721, -714, -707, -700, -693, -686, -679, -672, -665, -658, -651, -644, -637, -630, -623, -616, -609, -602, -595, -588, -581, -574, -567, -560, -553, -546, -539, -532, -525, -518, -511, -504, -497, -490, -483, -476, -469, -462, -455, -448, -441, -434, -427, -420, -413, -406, -399, -392, -385, -378, -371, -364, -357, -350, -343, -336, -329, -322, -315, -308, -301, -294, -287, -280, -273, -266, -259, -252, -245, -238, -231, -224, -217, -210, -203, -196, -189, -182, -175, -168, -161, -154, -147, -140, -133, -126, -119, -112, -105, -98, -91, -84, -77, -70, -63, -56, -49, -42, -35, -28, -21, -14, -7, 1, 8, 15, 22, 29, 36, 43, 50, 57, 64, 71, 78, 85, 92, 99, 106, 113, 120, 127, 134, 141, 148, 155, 162, 169, 176, 183, 190, 197, 204, 211, 218, 225, 232, 239, 246, 253, 260, 267, 274, 281, 288, 295, 302, 309, 316, 323, 330, 337, 344, 351, 358, 365, 372, 379, 386, 393, 400, 407, 414, 421, 428, 435, 442, 449, 456, 463, 470, 477, 484, 491, 498, 505, 512, 519, 526, 533, 540, 547, 554, 561, 568, 575, 582, 589, 596, 603, 610, 617, 624, 631, 638, 645, 652, 659, 666, 673, 680, 687, 694, 701, 708, 715, 722, 729, 736, 743, 750, 757, 764, 771, 778, 785, 792, 799, 806, 813, 820, 827, 834), (-837, -830, -823, -816, -809, -802, -795, -788, -781, -774, -767, -760, -753, -746, -739, -732, -725, -718, -711, -704, -697, -690, -683, -676, -669, -662, -655, -648, -641, -634, -627, -620, -613, -606, -599, -592, -585, -578, -571, -564, -557, -550, -543, -536, -529, -522, -515, -508, -501, -494, -487, -480, -473, -466, -459, -452, -445, -438, -431, -424, -417, -410, -403, -396, -389, -382, -375, -368, -361, -354, -347, -340, -333, -326, -319, -312, -305, -298, -291, -284, -277, -270, -263, -256, -249, -242, -235, -228, -221, -214, -207, -200, -193, -186, -179, -172, -165, -158, -151, -144, -137, -130, -123, -116, -109, -102, -95, -88, -81, -74, -67, -60, -53, -46, -39, -32, -25, -18, -11, -4, 4, 11, 18, 25, 32, 39, 46, 53, 60, 67, 74, 81, 88, 95, 102, 109, 116, 123, 130, 137, 144, 151, 158, 165, 172, 179, 186, 193, 200, 207, 214, 221, 228, 235, 242, 249, 256, 263, 270, 277, 284, 291, 298, 305, 312, 319, 326, 333, 340, 347, 354, 361, 368, 375, 382, 389, 396, 403, 410, 417, 424, 431, 438, 445, 452, 459, 466, 473, 480, 487, 494, 501, 508, 515, 522, 529, 536, 543, 550, 557, 564, 571, 578, 585, 592, 599, 606, 613, 620, 627, 634, 641, 648, 655, 662, 669, 676, 683, 690, 697, 704, 711, 718, 725, 732, 739, 746, 753, 760, 767, 774, 781, 788, 795, 802, 809, 816, 823, 830, 837), (-835, -828, -821, -814, -807, -800, -793, -786, -779, -772, -765, -758, -751, -744, -737, -730, -723, -716, -709, -702, -695, -688, -681, -674, -667, -660, -653, -646, -639, -632, -625, -618, -611, -604, -597, -590, -583, -576, -569, -562, -555, -548, -541, -534, -527, -520, -513, -506, -499, -492, -485, -478, -471, -464, -457, -450, -443, -436, -429, -422, -415, -408, -401, -394, -387, -380, -373, -366, -359, -352, -345, -338, -331, -324, -317, -310, -303, -296, -289, -282, -275, -268, -261, -254, -247, -240, -233, -226, -219, -212, -205, -198, -191, -184, -177, -170, -163, -156, -149, -142, -135, -128, -121, -114, -107, -100, -93, -86, -79, -72, -65, -58, -51, -44, -37, -30, -23, -16, -9, -2, 6, 13, 20, 27, 34, 41, 48, 55, 62, 69, 76, 83, 90, 97, 104, 111, 118, 125, 132, 139, 146, 153, 160, 167, 174, 181, 188, 195, 202, 209, 216, 223, 230, 237, 244, 251, 258, 265, 272, 279, 286, 293, 300, 307, 314, 321, 328, 335, 342, 349, 356, 363, 370, 377, 384, 391, 398, 405, 412, 419, 426, 433, 440, 447, 454, 461, 468, 475, 482, 489, 496, 503, 510, 517, 524, 531, 538, 545, 552, 559, 566, 573, 580, 587, 594, 601, 608, 615, 622, 629, 636, 643, 650, 657, 664, 671, 678, 685, 692, 699, 706, 713, 720, 727, 734, 741, 748, 755, 762, 769, 776, 783, 790, 797, 804, 811, 818, 825, 832, 839), (-839, -832, -825, -818, -811, -804, -797, -790, -783, -776, -769, -762, -755, -748, -741, -734, -727, -720, -713, -706, -699, -692, -685, -678, -671, -664, -657, -650, -643, -636, -629, -622, -615, -608, -601, -594, -587, -580, -573, -566, -559, -552, -545, -538, -531, -524, -517, -510, -503, -496, -489, -482, -475, -468, -461, -454, -447, -440, -433, -426, -419, -412, -405, -398, -391, -384, -377, -370, -363, -356, -349, -342, -335, -328, -321, -314, -307, -300, -293, -286, -279, -272, -265, -258, -251, -244, -237, -230, -223, -216, -209, -202, -195, -188, -181, -174, -167, -160, -153, -146, -139, -132, -125, -118, -111, -104, -97, -90, -83, -76, -69, -62, -55, -48, -41, -34, -27, -20, -13, -6, 2, 9, 16, 23, 30, 37, 44, 51, 58, 65, 72, 79, 86, 93, 100, 107, 114, 121, 128, 135, 142, 149, 156, 163, 170, 177, 184, 191, 198, 205, 212, 219, 226, 233, 240, 247, 254, 261, 268, 275, 282, 289, 296, 303, 310, 317, 324, 331, 338, 345, 352, 359, 366, 373, 380, 387, 394, 401, 408, 415, 422, 429, 436, 443, 450, 457, 464, 471, 478, 485, 492, 499, 506, 513, 520, 527, 534, 541, 548, 555, 562, 569, 576, 583, 590, 597, 604, 611, 618, 625, 632, 639, 646, 653, 660, 667, 674, 681, 688, 695, 702, 709, 716, 723, 730, 737, 744, 751, 758, 765, 772, 779, 786, 793, 800, 807, 814, 821, 828, 835), (-836, -829, -822, -815, -808, -801, -794, -787, -780, -773, -766, -759, -752, -745, -738, -731, -724, -717, -710, -703, -696, -689, -682, -675, -668, -661, -654, -647, -640, -633, -626, -619, -612, -605, -598, -591, -584, -577, -570, -563, -556, -549, -542, -535, -528, -521, -514, -507, -500, -493, -486, -479, -472, -465, -458, -451, -444, -437, -430, -423, -416, -409, -402, -395, -388, -381, -374, -367, -360, -353, -346, -339, -332, -325, -318, -311, -304, -297, -290, -283, -276, -269, -262, -255, -248, -241, -234, -227, -220, -213, -206, -199, -192, -185, -178, -171, -164, -157, -150, -143, -136, -129, -122, -115, -108, -101, -94, -87, -80, -73, -66, -59, -52, -45, -38, -31, -24, -17, -10, -3, 5, 12, 19, 26, 33, 40, 47, 54, 61, 68, 75, 82, 89, 96, 103, 110, 117, 124, 131, 138, 145, 152, 159, 166, 173, 180, 187, 194, 201, 208, 215, 222, 229, 236, 243, 250, 257, 264, 271, 278, 285, 292, 299, 306, 313, 320, 327, 334, 341, 348, 355, 362, 369, 376, 383, 390, 397, 404, 411, 418, 425, 432, 439, 446, 453, 460, 467, 474, 481, 488, 495, 502, 509, 516, 523, 530, 537, 544, 551, 558, 565, 572, 579, 586, 593, 600, 607, 614, 621, 628, 635, 642, 649, 656, 663, 670, 677, 684, 691, 698, 705, 712, 719, 726, 733, 740, 747, 754, 761, 768, 775, 782, 789, 796, 803, 810, 817, 824, 831, 838), (-834, -827, -820, -813, -806, -799, -792, -785, -778, -771, -764, -757, -750, -743, -736, -729, -722, -715, -708, -701, -694, -687, -680, -673, -666, -659, -652, -645, -638, -631, -624, -617, -610, -603, -596, -589, -582, -575, -568, -561, -554, -547, -540, -533, -526, -519, -512, -505, -498, -491, -484, -477, -470, -463, -456, -449, -442, -435, -428, -421, -414, -407, -400, -393, -386, -379, -372, -365, -358, -351, -344, -337, -330, -323, -316, -309, -302, -295, -288, -281, -274, -267, -260, -253, -246, -239, -232, -225, -218, -211, -204, -197, -190, -183, -176, -169, -162, -155, -148, -141, -134, -127, -120, -113, -106, -99, -92, -85, -78, -71, -64, -57, -50, -43, -36, -29, -22, -15, -8, -1, 7, 14, 21, 28, 35, 42, 49, 56, 63, 70, 77, 84, 91, 98, 105, 112, 119, 126, 133, 140, 147, 154, 161, 168, 175, 182, 189, 196, 203, 210, 217, 224, 231, 238, 245, 252, 259, 266, 273, 280, 287, 294, 301, 308, 315, 322, 329, 336, 343, 350, 357, 364, 371, 378, 385, 392, 399, 406, 413, 420, 427, 434, 441, 448, 455, 462, 469, 476, 483, 490, 497, 504, 511, 518, 525, 532, 539, 546, 553, 560, 567, 574, 581, 588, 595, 602, 609, 616, 623, 630, 637, 644, 651, 658, 665, 672, 679, 686, 693, 700, 707, 714, 721, 728, 735, 742, 749, 756, 763, 770, 777, 784, 791, 798, 805, 812, 819, 826, 833, 840), (-838, -831, -824, -817, -810, -803, -796, -789, -782, -775, -768, -761, -754, -747, -740, -733, -726, -719, -712, -705, -698, -691, -684, -677, -670, -663, -656, -649, -642, -635, -628, -621, -614, -607, -600, -593, -586, -579, -572, -565, -558, -551, -544, -537, -530, -523, -516, -509, -502, -495, -488, -481, -474, -467, -460, -453, -446, -439, -432, -425, -418, -411, -404, -397, -390, -383, -376, -369, -362, -355, -348, -341, -334, -327, -320, -313, -306, -299, -292, -285, -278, -271, -264, -257, -250, -243, -236, -229, -222, -215, -208, -201, -194, -187, -180, -173, -166, -159, -152, -145, -138, -131, -124, -117, -110, -103, -96, -89, -82, -75, -68, -61, -54, -47, -40, -33, -26, -19, -12, -5, 3, 10, 17, 24, 31, 38, 45, 52, 59, 66, 73, 80, 87, 94, 101, 108, 115, 122, 129, 136, 143, 150, 157, 164, 171, 178, 185, 192, 199, 206, 213, 220, 227, 234, 241, 248, 255, 262, 269, 276, 283, 290, 297, 304, 311, 318, 325, 332, 339, 346, 353, 360, 367, 374, 381, 388, 395, 402, 409, 416, 423, 430, 437, 444, 451, 458, 465, 472, 479, 486, 493, 500, 507, 514, 521, 528, 535, 542, 549, 556, 563, 570, 577, 584, 591, 598, 605, 612, 619, 626, 633, 640, 647, 654, 661, 668, 675, 682, 689, 696, 703, 710, 717, 724, 731, 738, 745, 752, 759, 766, 773, 780, 787, 794, 801, 808, 815, 822, 829, 836))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_symbols</value></param>
<param><key>value</key><value>((-1, 1, -1, -1, -1, -1, 1, -1, 1, -1, -1, 1, 1, 1, 1, 1, -1, -1, 1, 1, 1, 1, 1, -1, -1, 1, -1, 1, 1, 1, -1, -1, -1, -1, 1, 1, 1, -1, 1, 1, 1, -1, -1, 1, -1, -1, 1, -1, 1, 1, -1, -1, -1, -1, -1, 1, 1, 1, -1, -1, -1, -1, 1, -1, 1, -1, -1, 1, -1, 1, 1, 1, -1, 1, 1, -1, -1, -1, -1, 1, 1, 1, 1, 1, 1, 1, -1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, -1, 1, 1, -1, -1, 1, -1, -1, 1, 1, 1, 1, 1, -1, 1, -1, -1, 1, -1, 1, -1, 1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, 1, 1, -1, -1, -1, -1, -1, -1, -1, -1, -1, 1, 1, -1, 1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, 1, -1, -1, -1, 1, 1, -1, 1, 1, -1, 1, 1, -1, 1, -1, 1, -1, -1, 1, -1, -1, 1, -1, 1, -1, 1, 1, -1, 1, -1, 1, -1, 1, -1, 1, -1, 1, 1, -1, 1, -1, 1, -1, -1, 1, -1, 1, 1, 1, 1, 1, 1, 1, 1, -1, 1, 1, 1, -1, -1, 1, 1, 1, -1, 1, 1, 1, 1, 1), (-1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, -1, 1, -1, -1, 1, -1, -1, -1, -1, -1, 1, -1, 1, -1, 1, 1, 1, -1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, 1, 1, -1, 1, -1, -1, 1, 1, 1, -1, -1, 1, -1, 1, -1, -1, 1, -1, -1, 1, 1, 1, 1, -1, -1, 1, -1, -1, -1, 1, -1, 1, -1, 1, 1, -1, 1, 1, 1, 1, -1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, 1, -1, 1, -1, -1, -1, -1, -1, -1, 1, -1, 1, 1, 1, -1, -1, 1, -1, 1, -1, 1, -1, -1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, 1, 1, -1, 1, -1, -1, -1, -1, 1, 1, 1, 1, 1, -1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, 1, -1, 1, -1, -1, -1, 1, 1, 1, 1, -1, -1, -1, 1, 1, 1, 1, 1, -1, -1, 1, -1, 1, 1, -1, -1, 1, 1, 1, -1, 1, 1, 1, 1, 1, 1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, 1, 1, 1, 1), (1, -1, -1, 1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, 1, -1, 1, 1, -1, -1, 1, 1, -1, -1, 1, 1, -1, -1, 1, 1, -1, -1, -1, 1, 1, -1, -1, -1, 1, 1, 1, -1, -1, -1, 1, 1, 1, 1, -1, -1, -1, 1, -1, -1, -1, 1, -1, -1, 1, 1, 1, 1, -1, 1, 1, 1, -1, 1, -1, -1, -1, 1, 1, 1, 1, -1, 1, 1, 1, -1, -1, 1, 1, 1, 1, -1, 1, -1, 1, -1, 1, -1, -1, 1, -1, -1, 1, 1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, -1, 1, 1, -1, -1, -1, 1, -1, -1, -1, -1, 1, -1, 1, 1, 1, -1, -1, 1, -1, 1, -1, 1, -1, 1, -1, 1, 1, -1, -1, 1, -1, 1, 1, -1, 1, -1, 1, 1, 1, -1, 1, 1, -1, 1, -1, -1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, 1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, 1, -1, -1, -1, -1, 1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, -1, -1, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, -1, 1, -1, -1), (-1, 1, 1, -1, 1, 1, 1, 1, 1, -1, 1, 1, -1, -1, -1, 1, -1, -1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, 1, -1, -1, 1, 1, 1, 1, 1, -1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, -1, -1, 1, 1, -1, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, 1, 1, -1, 1, 1, 1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, -1, -1, -1, 1, 1, 1, 1, 1, 1, 1, -1, 1, 1, 1, 1, 1, -1, 1, -1, 1, 1, -1, -1, 1, 1, -1, -1, 1, 1, 1, -1, -1, -1, -1, -1, 1, 1, -1, 1, 1, 1, 1, 1, 1, -1, 1, 1, 1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, -1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, -1, -1, -1, -1, -1, 1, 1, 1, 1, 1, -1, -1, 1, 1, 1, 1, -1, -1, -1, -1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, 1, 1, -1, 1, 1, 1, -1, -1, 1, -1, 1, -1, 1, -1, -1, -1, -1, 1, 1, 1, -1, 1, -1, -1, 1, 1, -1, 1, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, 1, -1, -1), (1, -1, 1, 1, -1, -1, 1, 1, -1, -1, -1, 1, 1, -1, -1, 1, -1, -1, -1, 1, -1, -1, 1, 1, 1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, -1, 1, 1, -1, -1, 1, 1, -1, -1, -1, -1, -1, -1, 1, 1, -1, 1, 1, -1, -1, 1, 1, 1, 1, -1, -1, -1, -1, 1, 1, 1, 1, 1, -1, 1, 1, -1, 1, 1, -1, 1, -1, -1, -1, -1, -1, -1, -1, 1, 1, 1, 1, -1, 1, -1, 1, -1, -1, -1, 1, -1, -1, -1, 1, -1, -1, 1, 1, 1, 1, -1, 1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, -1, -1, 1, 1, 1, -1, 1, 1, -1, 1, -1, -1, -1, 1, 1, 1, -1, -1, 1, 1, -1, -1, -1, -1, -1, -1, 1, 1, -1, 1, 1, -1, 1, 1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, -1, -1, 1, 1, 1, 1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, 1, -1, 1, 1, 1, 1, -1, 1, 1, 1, 1, -1, -1, 1, -1, -1, 1, 1, -1, -1, -1, -1, 1, 1, 1, -1, -1, 1, 1, 1, 1, -1, 1, 1, 1, -1, -1, 1, -1, -1, 1, 1, 1, 1, 1, -1, -1, 1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1), (1, 1, -1, -1, -1, 1, 1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, -1, -1, -1, -1, 1, 1, -1, 1, -1, -1, -1, 1, 1, 1, -1, -1, 1, 1, -1, -1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, -1, -1, -1, -1, -1, 1, -1, 1, -1, 1, -1, -1, 1, 1, 1, 1, -1, -1, 1, -1, -1, -1, 1, -1, -1, -1, 1, 1, -1, 1, -1, -1, -1, 1, -1, -1, -1, 1, -1, -1, 1, -1, -1, 1, 1, -1, -1, -1, -1, -1, -1, -1, 1, 1, -1, -1, -1, -1, 1, -1, -1, 1, 1, -1, 1, 1, -1, -1, 1, -1, -1, -1, 1, -1, -1, -1, -1, -1, -1, -1, 1, 1, -1, 1, -1, -1, -1, 1, -1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, 1, -1, -1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, 1, -1, 1, 1, -1, 1, 1, -1, 1, -1, -1, -1, -1, -1, -1, 1, 1, 1, 1, 1, -1, -1, -1, 1, 1, 1, -1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, 1, 1, 1, 1, -1, 1, -1, -1, -1, -1, 1, -1, 1, 1, 1, -1, -1, -1, 1, 1, 1, 1, -1, 1, 1, 1, 1, 1, 1, 1, 1, -1, 1, 1, -1, -1, -1, -1, 1), (1, 1, 1, -1, -1, 1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, 1, 1, 1, 1, -1, -1, -1, 1, 1, -1, -1, -1, 1, 1, -1, 1, 1, 1, 1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, -1, 1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, -1, -1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, -1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, -1, -1, 1, 1, 1, 1, -1, 1, 1, -1, -1, 1, -1, -1, -1, -1, -1, -1, 1, -1, -1, -1, 1, -1, -1, 1, -1, -1, 1, -1, 1, -1, -1, 1, 1, -1, -1, -1, -1, 1, -1, 1, 1, -1, -1, 1, 1, 1, 1, 1, -1, 1, -1, 1, -1, -1, -1, 1, -1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, -1, -1, 1, -1, 1, 1, -1, 1, -1, -1, -1, 1, 1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, 1, -1, -1, -1, 1, -1, -1, -1, 1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 1, -1, -1, -1, -1, -1, -1, -1, -1, -1, -1))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>150e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sts</value></param>
<param><key>value</key><value>[0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0,-2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 0, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 2, 0, 0, 0, 2, 0, 0, 0, -2, 0, 0, 0, -2, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_size</value></param>
<param><key>value</key><value>1536</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>2560*2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>512</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_2_0</value></param>
<param><key>file</key><value>/media/hitesh/New Volume/BTP/rx</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1</value></param>
<param><key>file</key><value>/media/hitesh/New Volume/BTP/tx</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>.05</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>length_tag_key</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
<param><key>align_output</key><value>True</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>length_tag_key</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>2048</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Rx'd Packets</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1440</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>header_mod.points()</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_1_0</value></param>
<param><key>constellation</key><value>header_mod.base()</value></param>
</block>
<block>
<key>digital_ofdm_carrier_allocator_cvc</key>
<param><key>id</key><value>digital_ofdm_carrier_allocator_cvc_0_0_0_0_0</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>sync_words</key><value>(sts,lts)</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>input_size</key><value>fft_len</value></param>
<param><key>tagname</key><value>length_tag_key</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>rolloff</key><value>rolloff</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>tuple([1/52**.5] * 2048)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>tuple([1/52**.5] * 2048)</value></param>
</block>
<block>
<key>foo_packet_pad2</key>
<param><key>id</key><value>foo_packet_pad2_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>.043</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>pad_front</key><value>2880</value></param>
<param><key>pad_tail</key><value>5000</value></param>
</block>
<block>
<key>ieee802_22_moving_average_xx</key>
<param><key>id</key><value>ieee802_22_moving_average_xx_0</value></param>
<param><key>length</key><value>window_size</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>ieee802_22_moving_average_xx</key>
<param><key>id</key><value>ieee802_22_moving_average_xx_0_0</value></param>
<param><key>length</key><value>window_size+512</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>ieee802_22_ofdm_decode_signal</key>
<param><key>id</key><value>ieee802_22_ofdm_decode_signal_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>ieee802_22_ofdm_equalize_symbols</key>
<param><key>id</key><value>ieee802_22_ofdm_equalize_symbols_0</value></param>
<param><key>algo</key><value>ieee802_22.LINEAR_COMB</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_22_ofdm_sync_long</key>
<param><key>id</key><value>ieee802_22_ofdm_sync_long_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sync_length</key><value>5120</value></param>
</block>
<block>
<key>ieee802_22_ofdm_sync_short</key>
<param><key>id</key><value>ieee802_22_ofdm_sync_short_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
<param><key>min_plateau</key><value>119</value></param>
<param><key>threshold</key><value>0.85*.75</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio.digital.utils import tagged_streams</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>tx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>tx</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024*2</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>ieee802_22_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>ieee802_22_ofdm_sync_long_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>ieee802_22_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>ieee802_22_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>ieee802_22_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>blocks_file_sink_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>digital_ofdm_carrier_allocator_cvc_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_1_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_carrier_allocator_cvc_0_0_0_0_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>foo_packet_pad2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>ieee802_22_ofdm_equalize_symbols_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_22_moving_average_xx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_22_moving_average_xx_0</source_block_id><sink_block_id>ieee802_22_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_22_moving_average_xx_0_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_22_ofdm_decode_signal_0</source_block_id><sink_block_id>blocks_vector_to_stream_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_22_ofdm_equalize_symbols_0</source_block_id><sink_block_id>ieee802_22_ofdm_decode_signal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_22_ofdm_sync_long_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_22_ofdm_sync_short_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_22_ofdm_sync_short_0</source_block_id><sink_block_id>blocks_tag_debug_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_22_ofdm_sync_short_0</source_block_id><sink_block_id>ieee802_22_ofdm_sync_long_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
